# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W204S Series STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c GPIO.c timer.c USART.C main.c
  group New Group
    ./: config.h delay.h GPIO.h STC15Fxxxx.H timer.h USART.h
